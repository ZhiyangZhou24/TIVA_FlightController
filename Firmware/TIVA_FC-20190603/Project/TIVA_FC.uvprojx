# Keil uVision project TIVA_FC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIVA_FC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: ..\Core\inc;..\Libraries\inc;..\main;..\Peripheraldriver\inc;..\Libraries\Driverlib\ccs\Debug;..\Libraries\Driverlib;..\Applications\Inc;..\Peripheraldriver;..\HardWareDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ../main/: main.c include.h
  group Applications
    ../Applications/Src/: App_RadioLink.c matrix.C
  group Controller
    ../Applications/Src/: time.c imu.c mymath.c parameter.c rc.c ctrl.c filter.c data_transfer.c scheduler.c height_ctrl.c
  group Sensers
    ../HardWareDriver/src/: ultrasonic.c ICM_20602.C IST8310.c NRF24L01.c ms5611.c
  group PeriphDriver
    ../Peripheraldriver/src/: MY_EEPROM.c MY_PWM.c MY_SPI.c MY_TIMER.c MY_UART.c MY_I2C.c
    ../Applications/Src/: led_task.c
  group Libraries
    ../Libraries/Driverlib/: cpu.c eeprom.c fpu.c gpio.c interrupt.c pwm.c ssi.c sysctl.c systick.c timer.c uart.c i2c.c
    ../Peripheraldriver/: uartstdio.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
